# Keil uVision project dsbl.uvprojx, settings and files
target dsbl (6190000::V6.19::ARMCLANG)
  device: LPC55S36JBD100 NXP
  pack: NXP.LPC55S36_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: dsbl
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_LPC55S36JBD100, MCUXPRESSO_SDK SDK_DEBUGCONSOLE_UART
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../devices/LPC55S36/utilities/debug_console_lite;../../../../../devices/LPC55S36/drivers/flash;../../../../../devices/LPC55S36/drivers;..\..\..\..\..\devices\LPC55S36\utilities\str;../../../../../devices/LPC55S36;../../../../../components/uart;../../../../../components/lists;../../../../../CMSIS/Core/Include;..\src;..\src\dimage;..\src\mcuboot
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x20040000 size 0x4000
  memory RVCT7: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S36_flash.scf
  link misc: --remove --entry=Reset_Handler
  group source
    ../src/: main.c memory.c memory.h sbl_api.c sbl_api.h sbl_config.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../devices/LPC55S36/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
    ../../../../../devices/LPC55S36/utilities/str/: fsl_str.c
  group drivers/flash/src
    ../../../../../devices/LPC55S36/drivers/flash/src/: fsl_flash.c
  group drivers/flash
    ../../../../../devices/LPC55S36/drivers/flash/: fsl_flash.h fsl_flash_ffr.h fsl_flexspi_nor_flash.h
  group drivers
    ../../../../../devices/LPC55S36/drivers/: fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_iocon.h fsl_gpio.h fsl_gpio.c fsl_inputmux.h fsl_inputmux.c fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_reset.h fsl_reset.c fsl_inputmux_connections.h
  group device
    ../../../../../devices/LPC55S36/: fsl_device_registers.h LPC55S36.h LPC55S36_features.h system_LPC55S36.c system_LPC55S36.h
  group startup
    ../../../../../devices/LPC55S36/arm/: startup_LPC55S36.S
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group mcuboot
    ../src/mcuboot/: kptl.c mcuboot.c
  group dimage
    ../src/dimage/: crc32.c dimage.c
